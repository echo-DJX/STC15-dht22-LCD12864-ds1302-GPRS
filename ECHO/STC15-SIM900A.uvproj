# Keil uVision project STC15-SIM900A.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15-SIM900A +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 bsp.c dht22.c display.c ds1302.c LCD12864.c main.c UART.c
